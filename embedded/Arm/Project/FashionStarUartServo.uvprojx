# Keil uVision project FashionStarUartServo.uvprojx, settings and files
target FashionStarUartServo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FashionStarUartServo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\FWlib\src;..\Libraries\FWlib\inc;..\Project;..\User;..\User\usart;..\User\ring_buffer;..\User\sys_tick;..\User\fashion_star_uart_servo;..\APP;..\APP\LCD;..\APP\LED;..\system\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../User/: main.c
    ../User/usart/: usart.c
    ../User/ring_buffer/: ring_buffer.c
    ../User/sys_tick/: sys_tick.c
    ../User/fashion_star_uart_servo/: fashion_star_uart_servo.c
  group APP
    ../APP/: PWM.c PWM.h servo.c servo.h
    ../APP/LCD/: lcd.c lcd_init.c zk.c
    ../APP/LED/: led.c
    ./: motor.c motor.h board.c board.h
  group system
    ../system/sys/: sys.c
    ./: fifo.c fifo.h
software components: CMSIS:CORE 6.1.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
